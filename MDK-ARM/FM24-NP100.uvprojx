# Keil uVision project FM24-NP100.uvprojx, settings and files
target FM24-NP100 (6160000::V6.16::ARMCLANG)
  device: STM32F303CCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FM24-NP100 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,STM32F303xC
  c include: ../code/Core/Inc;../code/Drivers/STM32F3xx_HAL_Driver/Inc;../code/Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../code/Drivers/CMSIS/Device/ST/STM32F3xx/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Application/User/Core
    ../code/Core/Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c ramp.c opamp.c periph.c
  group Drivers/STM32F3xx_HAL_Driver
    ../code/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../code/Core/Src/: system_stm32f3xx.c
software components: CMSIS:CORE 5.6.0
